Commit message: desync 추가

File: Dynamixel/dynamixel_control/urdf/AVATAR_URDF_Test3.urdf (robot description, URDF)
Before this commit: robot AVATAR_URDF_Test3, 22 links, 21 joints
Joints:
- joint joint8: axis 1 0 0 -> -1 0 0
